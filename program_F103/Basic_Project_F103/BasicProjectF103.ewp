# IAR project BasicProjectF103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: App; App\App_os_task\; App\Bsp_board_test\; Boards; Drivers; Drivers\Led; Drivers\I2C; Drivers\Oled; StartSystem; StartSystem\Delay; StartSystem\IncludeStm32; StartSystem\Startup; StartSystem\Sys; StartSystem\Usart; StartSystem\DebugUart; StartSystem\Usart\Xshell_cmd; ThirdParty; ThirdParty\UcosII\Config; ThirdParty\UcosII\Core; ThirdParty\UcosII\Port; User; User\Config; User\Interrupt; User\Main; Lib; Lib\Fwlib\Inc; Lib\Fwlib\Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BasicProjectF103.srec
  ILINK.IlinkOutputFile: BasicProjectF103.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/App_bsp/App_bsp_test
    App/Bsp_board_test/: bsp_board_test.c bsp_board_test.h
  group App/App_os_task
    App/App_os_task/: app_task.c app_task.h
  group Boards
    Boards/: boards.h
  group Drivers/I2C
    Drivers/I2C/: myiic.c myiic.h
  group Drivers/Led
    Drivers/Led/: led.c led.h
  group Drivers/Oled
    Drivers/Oled/: font.h lcd12864.c lcd_12864.h
  group Lib/Fwlib/Inc
    Lib/Fwlib/Inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Lib/Fwlib/Src
    Lib/Fwlib/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartSystem/Delay
    StartSystem/Delay/: delay.c delay.h
  group StartSystem/DubugUart
    StartSystem/DebugUart/: DebugSys.c DebugSys.h
  group StartSystem/IncludeStm32
    StartSystem/IncludeStm32/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group StartSystem/Startup
    StartSystem/Startup/: startup_stm32f10x_hd.s
  group StartSystem/Sys
    StartSystem/Sys/: sys.c sys.h
  group StartSystem/Usart
    StartSystem/Usart/: usart.c usart.h
  group StartSystem/Usart/Xshell_cmd
    StartSystem/Usart/Xshell_cmd/: xshell_cmd.c xshell_cmd.h
  group ThirdParty/UcosII/Config
    ThirdParty/UcosII/Config/: includes.h os_cfg.h
  group ThirdParty/UcosII/Core
    ThirdParty/UcosII/Core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ThirdParty/UcosII/Port
    ThirdParty/UcosII/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User/Config
    User/Config/: global_config.h stm32f10x_conf.h
  group User/Interrupt
    User/Interrupt/: stm32f10x_it.c stm32f10x_it.h
  group User/Main
    User/Main/: main.c main.h
