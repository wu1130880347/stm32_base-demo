<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Basic_Project_F103\BasicProjectF103.ewp</path>
    </project>
    <batchBuild />
</workspace>
